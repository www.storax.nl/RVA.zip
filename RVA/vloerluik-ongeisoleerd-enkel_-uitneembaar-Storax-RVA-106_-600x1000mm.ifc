Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: f7209bc6-7036-4b23-bd06-1085e8862899.ifc
Time: 2026-08-11T14:28:18
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik ongeïsoleerd enkel, uitneembaar Storax - RVA 106, 600x1000mm
In: Bouwlaag
Material: aluminium
Pset_WindowCommon - Rc-waarde: 0 m²·k/w
Pset_Data - WUID: AgAAAHgredADAAAAPesCAAV2SgAA2FMBAFJfAQBA7AIA2esCAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAAHgredADAAAAPesCAAV2SgAA2FMBAFJfAQBA7AIA2esCAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAA)); gewicht per st: 12 kg/st; STABU2: 43.31.10; dagmaatlengte: 600 mm; lengte: 685 mm; NAA.K.T: samengesteld_product_kozijn; Rc-waarde: 0 m²·k/w; breedte: 1085 mm; serie: RVA; afsluitbaar: True; hoogte: 35 mm; merk: Storax; breuklast: A15; type: 106; dagmaatbreedte: 1000 mm; omranding: aluminium; luik: aluminium
